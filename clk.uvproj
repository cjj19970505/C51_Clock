# Keil uVision project clk.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: clk
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led.c Input.c Input.h Time.h Time.c BinHelper.h ClockInterface.c ClockInterface.h Date.h Date.c Utility.c Utility.h DateInterface.h DateInterface.c TaskSelector.h TaskSelector.c TaskUtility.h TaskUtility.c TestTask.h TestTask.c StopwatchTask.h StopwatchTask.c AlarmTask.c AlarmTask.h RingtoneManager.h RingtoneManager.c
    ./Looper/: Looper.h Looper.c
    ./SegScreen/: SegScreen.c SegScreen.h
